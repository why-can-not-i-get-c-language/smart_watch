# Keil uVision project smart_watch.uvprojx, settings and files
target smart_watch (6240000::V6.24::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(16000000) FPU2 CPUTYPE("Cortex-M4")
  output: smart_watch +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,WATCH_TARGET_STM32
  c misc: -std=c11 -Werror -Wno-unused-parameter
  c include: .\User;.\Hardware;.\System;.\Application;.\Start;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Start\stm32f411_flash.sct
  group F00_工程基础
    User/: main.c board_config.h stm32f4xx_hal_conf.h
    Hardware/: board_port.c board_port.h i2c_bus.c i2c_bus.h spi_bus.c spi_bus.h uart_port.c uart_port.h buttons.c buttons.h ssd1306.c ssd1306.h
    Start/: stm32f4xx_it.c startup_stm32f411xe.s system_stm32f4xx.c stm32f411_flash.sct
    System/: crc32.c crc32.h scheduler.c scheduler.h settings.c settings.h watch_types.h
    Application/: watch_app.c watch_app.h watch_ui.c watch_ui.h
    Library/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_cm4.h LICENSE_CMSIS_CORE.txt LICENSE_ST_DEVICE.txt LICENSE_ST_HAL.txt LICENSE_ST_HAL_UPSTREAM.md mpu_armv7.h stm32f411xe.h stm32f4xx.h stm32f4xx_hal.c stm32f4xx_hal.h stm32f4xx_hal_adc.c stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.c stm32f4xx_hal_adc_ex.h stm32f4xx_hal_cortex.c stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.c stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma_ex.h stm32f4xx_hal_exti.c stm32f4xx_hal_exti.h stm32f4xx_hal_flash.c stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.c stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_spi.c stm32f4xx_hal_spi.h stm32f4xx_hal_tim.c stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.c stm32f4xx_hal_uart.h system_stm32f4xx.h stm32f4xx_ll_adc.h
    Library/Legacy/: stm32_hal_legacy.h
    ./: sources.cmake CMakeLists.txt
    ../plan/: task.md
    ../plan/design/: wiring.md
  group F01_时间与日期
    System/: time_service.c time_service.h
    ../plan/design/functions/: F01.md
  group F02_定时振动提醒
    Hardware/: tm6605.c tm6605.h
    Application/: reminder.c reminder.h
    ../plan/design/functions/: F02.md
  group F03_步数统计
    Hardware/: mpu6050.c mpu6050.h
    Application/: pedometer.c pedometer.h
    ../plan/design/functions/: F03.md
  group F04_抬腕亮屏
    Application/: wrist_wake.c wrist_wake.h
    ../plan/design/functions/: F04.md
  group F05_持续低活动提醒
    Application/: activity.c activity.h
    ../plan/design/functions/: F05.md
  group F06_蓝牙同步与设置
    Hardware/: ble_link.c ble_link.h
    System/: ble_protocol.c ble_protocol.h
    Application/: phone_sync.c phone_sync.h
    Application/android/: BleClient.kt PacketCodec.kt WatchRepository.kt WatchScreens.kt
    ../plan/design/functions/: F06.md
  group F07_历史记录
    Hardware/: w25q64.c w25q64.h
    System/: record_store.c record_store.h
    Application/android/: HistoryExporter.kt
    ../plan/design/functions/: F07.md
  group F08_电量估算与低电提醒
    Hardware/: battery_adc.c battery_adc.h
    Application/: battery_service.c battery_service.h
    ../plan/design/functions/: F08.md
  group F09_低功耗管理
    Application/: power_manager.c power_manager.h
    ../plan/design/functions/: F09.md
  group F13_静止心率测量
    Hardware/: max30102.c max30102.h
    Application/: health.c health.h
    ../plan/design/functions/: F13.md
  group F14_血氧估算
    ../plan/design/functions/: F14.md
  group F16_手动SOS
    Application/: safety.c safety.h
    Application/android/: SosCoordinator.kt
    ../plan/design/functions/: F16.md
  group F17_疑似跌倒与人工确认
    ../plan/design/functions/: F17.md
  group F19_无线固件升级
    Application/: ota.c ota.h
    User/: bootloader.c bootloader.h
    Application/android/: OtaSender.kt
    ../plan/design/functions/: F19.md
